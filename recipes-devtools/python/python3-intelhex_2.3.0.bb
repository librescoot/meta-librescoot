DESCRIPTION = "Python intelhex library"
HOMEPAGE = "https://pypi.python.org/pypi/IntelHex"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=4eba844696655c3eae07aca8e3a94772"

inherit pypi setuptools3
