DESCRIPTION = "Python wrapper for libusb1"
HOMEPAGE = "https://github.com/vpelletier/python-libusb1"
LICENSE = "LGPL-2.1+"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"

inherit pypi setuptools3
