DESCRIPTION = "ECDSA lib for python"
HOMEPAGE = "http://github.com/warner/python-ecdsa"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=66ffc5e30f76cbb5358fe54b645e5a1d"

SRC_URI[sha256sum] = "478cba7b62555866fcb3bb3fe985e06decbdb68ef55713c4e5ab98c57d508e61"

inherit pypi setuptools3
